<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32g431rb_uart_interrupt_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
